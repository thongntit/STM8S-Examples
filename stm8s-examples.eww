<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\2-CLK\CLK.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\3-EXTI\EXTI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\1-GPIO\GPIO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\4-ITC\ITC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\6-PWM\PWM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\5-TIM\TIM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


