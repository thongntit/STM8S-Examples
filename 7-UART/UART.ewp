# IAR project UART.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: C:\Users\nanol\Desktop\STM8S-Examples\7-UART\STM8S_StdPeriph_Driver\inc; C:\Users\nanol\Desktop\STM8S-Examples\7-UART\STM8S_StdPeriph_Driver\src; C:\Users\nanol\Desktop\STM8S-Examples\7-UART\STM8S_StdPeriph_Driver
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: UART.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group lib
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_uart1.c
  group user
    STM8S_StdPeriph_Driver/: main.c stm8s_it.c
